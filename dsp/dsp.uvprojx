# Keil uVision project dsp.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32F769NIHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.16.0
  cpu: IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) IROM(0x08000000,0x200000) IROM2(0x00200000,0x200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: dsp
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: main.c stm32f7xx_it.c
    ./dsp/: dsp.c dsp.h
software components: CMSIS:CORE 5.5.0, CMSIS:DSP 1.9.0-dev, Device:STM32Cube Framework:Classic 1.3.0, Device:STM32Cube HAL:Common 1.3.0, Device:STM32Cube HAL:Cortex 1.3.0, Device:STM32Cube HAL:GPIO 1.3.0, Device:STM32Cube HAL:PWR 1.3.0, Device:STM32Cube HAL:RCC 1.3.0, Device:Startup 1.2.5
