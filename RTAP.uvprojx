# Keil uVision project RTAP.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32F769NIHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.16.0
  cpu: IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) IROM(0x08000000,0x200000) IROM2(0x00200000,0x200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: RTAP
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32 STM32F7 STM32F769NIHx STM32F769I_DISCO DEBUG STM32F769xx LV_LVGL_H_INCLUDE_SIMPLE CONFIG_LV_FONT_MONTSERRAT_36=1 CONFIG_LV_FONT_MONTSERRAT_24=1  CONFIG_LV_FONT_MONTSERRAT_18=1 CONFIG_LV_FONT_MONTSERRAT_16=1 CONFIG_LV_USE_FILE_EXPLORER CONFIG_LV_DEF_REFR_PERIOD=33 CONFIG_LV_MEM_POOL_EXPAND_SIZE=2048 CONFIG_LV_MEM_SIZE=131072
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x76000
  memory RVCT10: RAM 0x20076000 size 0x4000
  group main
    ./: main.c stm32f7xx_it.c
  group Control
    ./Control/: controlThread.c controlThread.h controlConfig.h
  group ADC
    ./ADC/: adc.c adc.h
  group DAC
    ./DAC/: dac.c dac.h
  group DSP
    ./DSP/: audioConfig.h dsp.c dsp.h dspThread.c dspThread.h eqCoefficients.h
  group LCD
    ./LCD/: gui_threads.h gui.c gui.h gui_threads.c tft.c tft.h touchpad.c touchpad.h logo_rtap.c
    ./: lv_conf.h
  group MP3
    ./MP3/: MP3.c MP3.h
  group Radio
    ./radio/: radio.c radio.h
  group WEB
    ./WEB/: ThreadWeb.h HTTP_Server.c HTTP_Server_CGI.c ThreadWeb.c
  group WebFiles
    ./WebFiles/: filtros.cgi header.inc index.cgi mp3.cgi radio.cgi styles.css time.cgx xml_http.js Web.c
    ./WebFiles/imgs/: floppy-diskx32.png loopx32.png next-songx32.png play-pausex32.png prev-songx32.png RTAP.png sendx32.png
  group RTC
    ./RTC/: rtc.c rtcThread.c rtc.h rtcThread.h
  group I2C
    ./i2c/: i2c.c i2c.h
  group SD
    ./sd/: sd.c sd.h
software components: CMSIS:CORE 5.5.0, CMSIS:DSP 1.15.0, CMSIS:RTOS2:Keil RTX5 5.5.3, Compiler:Event Recorder 1.5.1, Compiler:I/O:File 1.2.0, Compiler:I/O:STDOUT 1.2.0, File System:CORE 6.14.1, File System:Drive:Memory Card 6.14.1, Network:CORE 7.15.0, Network:Interface:ETH 7.15.0, Network:Service:Web Server Compact 7.15.0, Network:Socket:TCP 7.15.0, Network:Socket:UDP 7.15.0, Board Support:Drivers:Basic I/O 1.1.0, Board Support:Drivers:LCD 1.1.0, Board Support:Drivers:SD 1.1.0, Board Support:Drivers:SDRAM 1.1.0, Board Support:Drivers:Touch Screen 1.1.0, Board Support:Touchscreen 1.1.0, CMSIS Driver:Ethernet MAC 1.12.0, CMSIS Driver:Ethernet PHY:LAN8742A 1.3.0, CMSIS Driver:I2C 1.13.0, CMSIS Driver:MCI 1.13.0, CMSIS Driver:USART 1.21.0, Device:STM32Cube Framework:Classic 1.3.0, Device:STM32Cube HAL:ADC 1.3.0, Device:STM32Cube HAL:Common 1.3.0, Device:STM32Cube HAL:Cortex 1.3.0, Device:STM32Cube HAL:DAC 1.3.0, Device:STM32Cube HAL:DMA 1.3.0, Device:STM32Cube HAL:DMA2D 1.3.0, Device:STM32Cube HAL:DSI 1.3.0, Device:STM32Cube HAL:GPIO 1.3.0, Device:STM32Cube HAL:I2C 1.3.0, Device:STM32Cube HAL:LTDC 1.3.0, Device:STM32Cube HAL:MMC 1.3.0, Device:STM32Cube HAL:PWR 1.3.0, Device:STM32Cube HAL:RCC 1.3.0, Device:STM32Cube HAL:RTC 1.3.0, Device:STM32Cube HAL:SD 1.3.0, Device:STM32Cube HAL:SDRAM 1.3.0, Device:STM32Cube HAL:TIM 1.3.0, Device:STM32Cube LL:Common 1.3.0, Device:STM32Cube LL:PWR 1.3.0, Device:STM32Cube LL:RCC 1.3.0, Device:STM32Cube LL:UTILS 1.3.0, Device:Startup 1.2.5, LVGL:Display 9.1.0, LVGL:Essential 9.1.0
