# Keil uVision project HTTP_Server.uvprojx, settings and files
target Debug (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F769NIHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.16.0
  cpu: IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) IROM(0x08000000,0x200000) IROM2(0x00200000,0x200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: HTTP_Server
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: HSE_VALUE=8000000
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
  group Source
    ./: HTTP_Server.c HTTP_Server_CGI.c main.c
    WebFiles/: Web.c
  group Web files
    ./WebFiles/: styles.css index.cgi filtros.cgi mp3.cgi radio.cgi header.inc time.cgx xml_http.js
    ./WebFiles/imgs/: floppy-diskx32.png loopx32.png next-songx32.png play-pausex32.png prev-songx32.png RTAP.png sendx32.png
target Release (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: HTTP_Server
  c flags: Optim=4 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: HSE_VALUE=25000000
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
software components: CMSIS:CORE 5.5.0, CMSIS:RTOS2:Keil RTX5 5.5.3, CMSIS:RTOS2:Keil RTX5 5.5.3, Compiler:Event Recorder 1.5.1, Network:CORE 7.15.0, Network:CORE 7.15.0, Network:Interface:ETH 7.15.0, Network:Service:Web Server Compact 7.15.0, Network:Socket:TCP 7.15.0, Network:Socket:UDP 7.15.0, CMSIS Driver:Ethernet MAC 2.10, CMSIS Driver:Ethernet MAC 1.12.0, CMSIS Driver:Ethernet PHY:LAN8742A 1.3.0, Device:STM32Cube Framework:Classic 1.8.1, Device:STM32Cube Framework:Classic 1.3.0, Device:STM32Cube HAL:ADC 1.8.1, Device:STM32Cube HAL:ADC 1.3.0, Device:STM32Cube HAL:Common 1.8.1, Device:STM32Cube HAL:Common 1.3.0, Device:STM32Cube HAL:Cortex 1.8.1, Device:STM32Cube HAL:Cortex 1.3.0, Device:STM32Cube HAL:DMA 1.8.1, Device:STM32Cube HAL:DMA 1.3.0, Device:STM32Cube HAL:GPIO 1.8.1, Device:STM32Cube HAL:GPIO 1.3.0, Device:STM32Cube HAL:PWR 1.8.1, Device:STM32Cube HAL:PWR 1.3.0, Device:STM32Cube HAL:RCC 1.8.1, Device:STM32Cube HAL:RCC 1.3.0, Device:STM32Cube HAL:SRAM 1.8.1, Device:STM32Cube HAL:SRAM 1.3.0, Device:Startup 2.6.3, Device:Startup 1.2.5
