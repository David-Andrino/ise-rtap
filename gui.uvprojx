# Keil uVision project gui.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32F769NIHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.16.0
  cpu: IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) IROM(0x08000000,0x200000) IROM2(0x00200000,0x200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: gui
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32 STM32F7 STM32F769NIHx STM32F769I_DISCO DEBUG STM32F769xx LV_LVGL_H_INCLUDE_SIMPLE CONFIG_LV_FONT_MONTSERRAT_24=1 CONFIG_LV_FONT_MONTSERRAT_16=1
  c include: .
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x76000
  memory RVCT10: RAM 0x20076000 size 0x4000
  group src
    ./: gui_threads.c gui_threads.h main.c main.h gui.c gui.h stm32f7xx_it.c
  group lvgmierdas
    ./hal_stm_lvgl/tft/: tft.c tft.h
    ./hal_stm_lvgl/touchpad/: touchpad.c touchpad.h
    ./: lv_conf.h
software components: CMSIS:CORE 5.5.0, CMSIS:RTOS2:Keil RTX5 5.5.3, Compiler:Event Recorder 1.5.1, Board Support:Drivers:Basic I/O 1.1.0, Board Support:Drivers:LCD 1.1.0, Board Support:Drivers:SDRAM 1.1.0, Board Support:Drivers:Touch Screen 1.1.0, Board Support:LED 1.1.0, Board Support:Touchscreen 1.1.0, Device:STM32Cube Framework:Classic 1.3.0, Device:STM32Cube HAL:Common 1.3.0, Device:STM32Cube HAL:Cortex 1.3.0, Device:STM32Cube HAL:DMA 1.3.0, Device:STM32Cube HAL:DMA2D 1.3.0, Device:STM32Cube HAL:DSI 1.3.0, Device:STM32Cube HAL:GPIO 1.3.0, Device:STM32Cube HAL:I2C 1.3.0, Device:STM32Cube HAL:LTDC 1.3.0, Device:STM32Cube HAL:PWR 1.3.0, Device:STM32Cube HAL:RCC 1.3.0, Device:STM32Cube HAL:SDRAM 1.3.0, Device:STM32Cube HAL:TIM 1.3.0, Device:Startup 1.2.5, LVGL:Display 9.1.0, LVGL:Essential 9.1.0
